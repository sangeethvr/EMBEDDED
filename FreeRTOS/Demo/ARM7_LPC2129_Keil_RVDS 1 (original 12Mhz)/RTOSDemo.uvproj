# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo_ARM (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOSDemo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS
  c include: .;..\..\Source\portable\RVDS\ARM7_LPC21xx;..\Common\include;..\..\Source\include
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Other
    ./: Startup.s main.c
    ./ParTest/: ParTest.c
    ./serial/: serial.c serialISR.s
  group FreeRTOS
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    ../../Source/portable/MemMang/: heap_2.c
  group Stadard Demo
    ../Common/Minimal/: flash.c comtest.c BlockQ.c dynamic.c PollQ.c semtest.c
target RTOSDemo_THUMB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOSDemo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: as above
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000

#include<pic.h>
void main()
{
int j,i;
TRISD=0xC0;
TRISB=0x00;
TRISC=0x00;
PORTB=0x00;
PORTD=0x00;
PORTC=0x00;
while(1)
{
if(RD6==1)
{
for(j=8;j>=0;j--)
{
PORTB=0xff>>j;
for(i=0;i<=5000;i++)
{}
}
}
else
{
PORTB=0x00;
}
if(RD7==1)
{
PORTC=0xff;
for(i=0;i<=5000;i++)
{}
PORTC=0x00;
for(i=0;i<=5000;i++)
{}
}
else
{
PORTC=0x00;
}
}
}
